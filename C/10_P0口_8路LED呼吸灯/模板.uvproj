# Keil uVision project 模板.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 模板 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Core\Inc;.\Drivers\Inc
  group Core
    ./Core/Src/: main.c
  group Drivers
    ./Drivers/Src/: lcd.c wiegand.c
